inherit pbuilder

LICENSE = "MIT"

SRC_URI = "git://github.com/linutronix/libgpio"
SRCREV = "${AUTOREV}"
S = "${WORKDIR}/git"

